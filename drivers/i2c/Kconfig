## drivers/i2c/Kconfig
```kconfig
# Copyright (c) 2026 Space Cubics Inc.
# SPDX-License-Identifier: Apache-2.0

if I2C

rsource "Kconfig.sc"

endif
```
